# Keil uVision project FW_992Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5708 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FF5) CLOCK(32000000) MODC2 DPC MDU_R515
  output: FW_992Pro +hex
  AfterMake: HexConvert.exe $D "#H"
  c flags: SizeSpeed=1
  c include: .\app;.\base
  group Source Group 1
    ./: STARTUP.A51 OPTIONS_SN8F5708.A51
  group app
    ./app/: main.c PID_operation.c lcd.c definition.c
  group base
    ./base/: adzh_10.c getkey.c ISP.c delay.c tmr.c gpio.c PWM.c EC11.c
